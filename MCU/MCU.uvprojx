# Keil uVision project MCU.uvprojx, settings and files
target TM4C123GH6PM (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MCU +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group SRC
    ./: main.c tm4c123gh6pm_registers.h Std_Types.h Compiler.h Platform_Types.h Std_BitMath.h
  group Dio
    ./: Dio.c Dio_Cfg.h Dio.h Dio_Lcfg.h
  group Port
    ./: Port.c Port_Cfg.h Port.h Port_PBcfg.c Port_Lcfg.c Port_Tm4c123gh6pmCfg.h Port_TM4C123GH6PM_Registers.h
  group Mcu
    ./: Mcu_Cfg.c Mcu_Cfg.h Mcu.h Mcu.c
  group Gpt
    ./: Gpt.c Gpt.h Gpt_Cfg.h
  group Pwm
    ./: Pwm.c Pwm.h Pwm_Cfg.h Pwm_Lcfg.c Pwm_Irq.c Pwm_PBcfg.c
  group Qei
    ./: Qei.c Qei.h Qei_TM4C123GH6PM_Registers.h Qei_PBcfg.c
  group Uart
    ./: Uart.c Uart.h Uart_TM4C123GH6PM_Registers.h Uart_PBcfg.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
